# Keil uVision project weatherstation.uvprojx, settings and files
target weatherstation (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: EFM32ZG222F32 Silicon Labs
  pack: Keil.EFM32ZGxxx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(24000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: weatherstation +hex
  AfterMake: fromelf.exe --bin --output obj\weatherstation.bin obj\weatherstation.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: EFM32ZG222F32,EFM32_HFXO_FREQ,_USART_ROUTELOC0_MASK,USART_ROUTEPEN_TXPEN
  c misc: --c99
  c include: ..\;..;..\emlib;..\emlib\inc;..\common\drivers\emwin;..\emdrv;..\common\drivers;..\emdrv\rtcdrv\inc;..\emdrv\rtcdrv\config;..\EFM32ZG\Include;..\Include;..\emdrv\spidrv\inc;..\emdrv\spidrv\config;..\emdrv\dmadrv\inc;..\emdrv\dmadrv\config;..\common\drivers
  asm define: EFM32ZG222F32
  asm include: ..\;..\..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\..\platform\Device\SiliconLabs\EFM32ZG\Include;..\..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\..\platform\emdrv\common\inc;..\..\..\..\..\..\platform\emdrv\rtcdrv\inc;..\..\..\..\..\..\platform\emdrv\rtcdrv\config;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\..\..\..\..\..\platform\middleware\glib;..\..\..\..\..\..\platform\middleware\glib\glib;..\..\..\..\..\..\platform\middleware\glib\dmd;..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../EFM32ZG/Source/: system_efm32zg.c
    ../EFM32ZG/Source/ARM/: startup_efm32zg.s
  group Drivers
    ../common/drivers/: udelay.c si7013.c i2cspm.c
    ../: si7021.c lcd.c
  group emlib
    ../emlib/src/: em_adc.c em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_leuart.c em_rtc.c em_usart.c em_i2c.c em_dma.c em_rmu.c
    ../: nrf24l01.c
  group Source
    ../: weatherstation.c
